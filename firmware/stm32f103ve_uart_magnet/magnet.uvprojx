# Keil uVision project magnet.uvprojx, settings and files
target STM32F103VE_UART_MAGNET (6240000::V6.24::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103ve_uart_magnet +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c misc: -std=c11 -Wall -Wextra -Wconversion -Wshadow -Werror
  c include: .\cmsis;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\firmware.sct
  group Application
    ./src/: main.c magnet_control.c
    ./inc/: magnet_control.h board_config.h stm32f10x_conf.h
  group CMSIS
    ./src/: system_stm32f10x.c
    ./cmsis/: stm32f10x.h system_stm32f10x.h core_cm3.h
  group Startup
    ./startup/: startup_stm32f10x_hd.s
